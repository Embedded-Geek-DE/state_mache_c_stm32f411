# Keil uVision project state_machine.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::..\..\..\..\..\..\Keil_v5\ARM\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: state_machine
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.c
  group drv
    ./: uart.c uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
